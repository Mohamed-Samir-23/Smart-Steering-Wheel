# Keil uVision project WIFI-Project-STM32f103.uvprojx, settings and files
target WIFI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WIFI-Project-STM32f103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1388
  group source
    ./src/: HESP_program.c MGPIO_program.c MRCC_program.c MSYSTICK_program.c MUART_program.c SWIFI_program.c MNVIC_program.c
  group include
    ./include/: HESP_interface.h HESP_private.h HESP_config.h LBIT_math.h LSTD_types.h MGPIO_config.h MGPIO_interface.h MGPIO_private.h MRCC_config.h MRCC_interface.h MRCC_private.h MSYSTICK_config.h MSYSTICK_interface.h MSYSTICK_private.h MUART_interface.h MUART_private.h SWIFI_interface.h SWIFI_private.h MNVIC_interface.h MNVIC_private.h
  group main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
